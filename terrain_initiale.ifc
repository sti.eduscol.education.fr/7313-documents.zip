Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Users\Utilisateur\Documents\BIM\Soutènement\terrain_initiale.ifc
Time: 2016-04-05T11:12:32
Author: Roger GODIN
Organization: Nemetschek AG, Konrad-Zuse-Platz 1, 81829 Munich / Germany
Written by: The EXPRESS Data Manager Version 5.02.0100.02 : 29 May 2013
Made in: Allplan 2014.1 13.07.2015 - 08:58:29

# IfcBuildingElementProxy
In: Leçon 0: Environnement du projet
Allplan Attributes - Unité: m³; NOI_UUID: 5e2b21b6-fb0d-11e5-83bb-7824afc948f4--0
